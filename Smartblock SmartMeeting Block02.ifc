Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2023-11-06T20:34:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.70.21 - Exporter 21.1.70.21 - Alternate UI 21.1.70.21
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 06 20:34:59 2023 * Host: DESKTOP-AEKBDFG * Database: C:\Users\mikal\AppData\Local\Temp\87b03589-96c9-4b52-8d13-b2810b825894\d8c136ec-b5cc-4132-aec1-51d0bbb5bbe1\ifc * Database version: 5507 * Database creation date: Mon Nov 06 20:34:51 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 06 20:34:51 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 06 20:34:51 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, All
LongName: All; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Pset_AirSideSystemInformation - Name: All
Pset_ProductRequirements - Name: All; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: All; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFurnishingElement: Smartblock - SmartMeeting Block02 M1:Basic01, Smartblock - SmartMeeting Block02 M1:Basic01:14866
In: All
Type - Classification: 5111 (Uniformat); Material: Gabriel Cura 68261 (2), RAL 9003 Signal White (4), RAL9005 Jet Black
Type - Constraints - Default Elevation: 265 mm; TD_Exterior_hard_: yes; TD_Exterior_soft_: no
Type - Dimensions - TD_Area_: 2.2 m2; TD_Depth_: 1000 mm; TD_Height_: 2235 mm; TD_Width_: 2200 mm
Type - Identity Data - Assembly Code: 5111; Keynote: 8192; Manufacturer: Smartblock Oy; Model: Basic01; TD_BIM_author_: Mika Leinonen, B.Eng, B.Arch.; TD_BIM_author_contact_information_: https://treedee.fi/home/contact-us/; TD_BIM_content_copyright_: Treedee Oy; TD_BIM_content_publish_date_: 28.10.2023; TD_BIM_content_publish_Revit_version_: Revit 2020.2.9; TD_Capacity_: Optimoitu kahdelle hengelle; TD_Collection_name_: SmartMeeting Block02, M1; TD_Model_ID_: Block02; Type Comments: Asennuskorkeus: Minimissään 2500 mm; Type Name: Basic01; URL: https://www.mysmartblock.com/product-page/smartmeeting-block02
Type - Materials and Finishes - TD_Center_post_color_: RAL 9003 Signal White; TD_End_edge_color_: RAL 9003 Signal White; TD_Exterior_color_: RAL 9003 Signal White; TD_Interior_color_: Gabriel Cura 68261; TD_Sofa_upholstery_: Gabriel Cura 68261; TD_Table_leg_color_: RAL 9003 Signal White
Type - Other - Category: Furniture Systems; Family Name: Smartblock - SmartMeeting Block02 M1
Type - Pset_ManufacturerTypeInformation - Manufacturer: Smartblock Oy
Type - Pset_ProductRequirements - Category: Furniture Systems
Type - Pset_QuantityTakeOff - Reference: Basic01
Material: PET Tumman harmaa, Fletco T393380, Lasi, RAL 9003 Signal White, RAL9005 Jet Black, Gabriel Cura 68261, Alumiini - matta
Constraints - Elevation from Level: 265 mm; Host: Level : All; Level: Level: All; Moves With Nearby Elements: no; Offset from Host: 265 mm
Dimensions - Area: 17.432 m2; Volume: 4.917 m3
Other - Family: Smartblock - SmartMeeting Block02 M1: Basic01; Family and Type: Smartblock - SmartMeeting Block02 M1: Basic01; Type: Smartblock - SmartMeeting Block02 M1: Basic01; Type Id: Smartblock - SmartMeeting Block02 M1: Basic01
Phasing - Phase Created: New Construction
